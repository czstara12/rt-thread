# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: .;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;libraries\SWM181_StdPeriph_Driver;..\..\..\components\libc\compilers\common\include;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\CMSIS\DeviceSupport;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;libraries\CMSIS\CoreSupport;..\..\..\components\libc\posix\io\poll;applications;..\..\..\components\drivers\include;drivers
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/SWM181_StdPeriph_Driver/: SWM181_uart.c SWM181_slcd.c SWM181_div.c SWM181_timr.c SWM181_port.c SWM181_exti.c SWM181_adc.c SWM181_flash.c SWM181_cordic.c SWM181_sleep.c SWM181_cmp.c SWM181_wdt.c SWM181_cache.c SWM181_gpio.c SWM181_dma.c SWM181_sdadc.c SWM181_spi.c SWM181_pwm.c SWM181_can.c SWM181_irqmux.c SWM181_i2c.c
    libraries/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
    libraries/CMSIS/DeviceSupport/: system_SWM181.c
